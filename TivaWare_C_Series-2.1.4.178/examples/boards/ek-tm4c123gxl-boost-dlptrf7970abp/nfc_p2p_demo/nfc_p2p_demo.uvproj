# Keil uVision project nfc_p2p_demo.uvproj, settings and files
target nfc_p2p_demo (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: nfc_p2p_demo
  AfterMake: fromelf --bin --output .\rvmdk\nfc_p2p_demo.bin .\rvmdk\nfc_p2p_demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c misc: --c99
  c include: .;..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: nfc_p2p_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c
    ../../../../nfclib/: iso14443a.c llcp.c nfc.c nfc_dep.c nfc_f.c nfc_p2p.c snep.c ssitrf79x0.c trf79x0.c
    ./: nfc_p2p_demo.c nfc_p2p_demo_debug.c startup_rvmdk.S
    ../../../../utils/: ringbuf.c uartstdio.c ustdlib.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
