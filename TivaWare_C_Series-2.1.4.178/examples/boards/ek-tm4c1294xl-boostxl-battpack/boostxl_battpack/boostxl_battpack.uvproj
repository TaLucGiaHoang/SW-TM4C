# Keil uVision project boostxl_battpack.uvproj, settings and files
target boostxl_battpack (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: boostxl_battpack
  AfterMake: fromelf --bin --output .\rvmdk\boostxl_battpack.bin .\rvmdk\boostxl_battpack.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: boostxl_battpack.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boostxl_battpack.c startup_rvmdk.S
    ../drivers/: buttons.c pinout.c
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
  group Documentation
    ./: readme.txt
