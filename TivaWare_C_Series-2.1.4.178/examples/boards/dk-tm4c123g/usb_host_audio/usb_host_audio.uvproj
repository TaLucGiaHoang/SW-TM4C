# Keil uVision project usb_host_audio.uvproj, settings and files
target usb_host_audio (ARM-ADS)
  device: TM4C123GH6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: usb_host_audio
  AfterMake: fromelf --bin --output .\rvmdk\usb_host_audio.bin .\rvmdk\usb_host_audio.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..;..\..\..\..;..\..\..\..\third_party;..\..\..\..\utils;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: usb_host_audio.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c cfal96x64x16.c slidemenuwidget.c usb_sound.c
    ../../../../third_party/fatfs/src/: ff.c
    ../../../../third_party/fatfs/port/: mmc-dk-tm4c123g.c
    ./: startup_rvmdk.S usb_host_audio.c
    ../../../../utils/: ustdlib.c wavfile.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
