# Keil uVision project nfc_p2p_demo.uvproj, settings and files
target nfc_p2p_demo (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: nfc_p2p_demo
  AfterMake: fromelf --bin --output .\rvmdk\nfc_p2p_demo.bin .\rvmdk\nfc_p2p_demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_TM4C129_RA0 UART_BUFFERED
  c misc: --c99
  c include: .;..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: nfc_p2p_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../../nfclib/: directmode.c iso14443a.c llcp.c nfc.c nfc_dep.c nfc_f.c nfc_p2p.c snep.c ssitrf79x0.c trf79x0.c
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c touch.c
    ./: images.c nfc_p2p_demo.c nfc_p2p_demo_debug.c screen.c startup_rvmdk.S
    ../../../../utils/: ringbuf.c uartstdio.c ustdlib.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
