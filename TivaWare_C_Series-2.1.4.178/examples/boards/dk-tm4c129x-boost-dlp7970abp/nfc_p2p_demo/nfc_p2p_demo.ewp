# IAR project nfc_p2p_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  ICCARM.CCDefines: ewarm; PART_TM4C129XNCZAD; TARGET_IS_TM4C129_RA0; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: nfc_p2p_demo.bin
  ILINK.IlinkOutputFile: nfc_p2p_demo.out
  ILINK.IlinkIcfFile: nfc_p2p_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ../../../../nfclib/: directmode.c iso14443a.c llcp.c nfc.c nfc_dep.c nfc_f.c nfc_p2p.c snep.c ssitrf79x0.c trf79x0.c
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c touch.c
    ./: images.c nfc_p2p_demo.c nfc_p2p_demo_debug.c screen.c startup_ewarm.c
    ../../../../utils/: ringbuf.c uartstdio.c ustdlib.c ustdlib.c
