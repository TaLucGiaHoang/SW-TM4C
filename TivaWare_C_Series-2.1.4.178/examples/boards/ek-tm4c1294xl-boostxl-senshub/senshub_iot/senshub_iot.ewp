# IAR project senshub_iot.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..; ..\..\..\..\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\third_party\FreeRTOS; ..\..\..\..\third_party\lwip-1.4.1\apps; ..\..\..\..\third_party\exosite; ..\..\..\..\third_party\FreeRTOS\Source\include; ..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\..\..\third_party\lwip-1.4.1\src\include; ..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\..\..\third_party; ..\..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: senshub_iot.bin
  ILINK.IlinkOutputFile: senshub_iot.out
  ILINK.IlinkIcfFile: senshub_iot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../sensorlib/ewarm/Exe/: sensorlib.a
  group Source
    ./: bmp180_task.c cloud_task.c command_task.c compdcm_task.c isl29023_task.c senshub_iot.c sht21_task.c startup_ewarm.c tmp006_task.c
    ../drivers/: buttons.c eth_client_lwip.c exosite_hal_lwip.c http.c pinout.c
    ../../../../utils/: cmdline.c flash_pb.c locator.c lwiplib.c ringbuf.c uartstdio.c ustdlib.c
    ../../../../third_party/exosite/: exosite.c exosite_meta.c
    ../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../../../../third_party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../third_party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.S
