# Keil uVision project senshub_iot.uvproj, settings and files
target senshub_iot (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: senshub_iot
  AfterMake: fromelf --bin --output .\rvmdk\senshub_iot.bin .\rvmdk\senshub_iot.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0 UART_BUFFERED
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\third_party\FreeRTOS;..\..\..\..\third_party\lwip-1.4.1\apps;..\..\..\..\third_party\exosite;..\..\..\..\third_party\FreeRTOS\Source\include;..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include;..\..\..\..\third_party\lwip-1.4.1\src\include;..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4;..\..\..\..\third_party;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: senshub_iot.sct
  link misc: --entry Reset_Handler
  group Source
    ./: bmp180_task.c cloud_task.c command_task.c compdcm_task.c isl29023_task.c senshub_iot.c sht21_task.c startup_rvmdk.S tmp006_task.c
    ../drivers/: buttons.c eth_client_lwip.c exosite_hal_lwip.c http.c pinout.c
    ../../../../utils/: cmdline.c flash_pb.c locator.c lwiplib.c ringbuf.c uartstdio.c ustdlib.c
    ../../../../third_party/exosite/: exosite.c exosite_meta.c
    ../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../../../../third_party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
  group Documentation
    ./: readme.txt
