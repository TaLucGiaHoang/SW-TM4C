# Keil uVision project temperature_tmp006.uvproj, settings and files
target temperature_tmp006 (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: temperature_tmp006
  AfterMake: fromelf --bin --output .\rvmdk\temperature_tmp006.bin .\rvmdk\temperature_tmp006.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: temperature_tmp006.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c pinout.c
    ./: startup_rvmdk.S temperature_tmp006.c
    ../../../../utils/: uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
  group Documentation
    ./: readme.txt
