# Keil uVision project hibernate.uvproj, settings and files
target hibernate (ARM-ADS)
  device: TM4C129ENCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: hibernate
  AfterMake: fromelf --bin --output .\rvmdk\hibernate.bin .\rvmdk\hibernate.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129ENCPDT TARGET_IS_TM4C129_RA0 SNOWFLAKE UART_BUFFERED
  c misc: --c99
  c include: .;..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: hibernate.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c pinout.c
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ./: hibernate.c hibernate_commands.c startup_rvmdk.S
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
