# IAR project aes128_ecb_encrypt.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129ENCPDT TexasInstruments TM4C129ENCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C129ENCPDT; TARGET_IS_TM4C129_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: aes128_ecb_encrypt.bin
  ILINK.IlinkOutputFile: aes128_ecb_encrypt.out
  ILINK.IlinkIcfFile: aes128_ecb_encrypt.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: aes128_ecb_encrypt.c startup_ewarm.c
    ../drivers/: pinout.c
    ../../../../utils/: uartstdio.c
