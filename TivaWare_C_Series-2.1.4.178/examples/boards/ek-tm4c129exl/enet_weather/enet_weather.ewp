# IAR project enet_weather.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129ENCPDT TexasInstruments TM4C129ENCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C129ENCPDT; TARGET_IS_TM4C129_RA0; LWIP_1_4_1; USE_HTTP_1_0; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..; ..\..\..\..\third_party\lwip-1.4.1\apps; ..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\..\..\third_party\lwip-1.4.1\src\include; ..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: enet_weather.bin
  ILINK.IlinkOutputFile: enet_weather.out
  ILINK.IlinkIcfFile: enet_weather.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../../../../utils/: cmdline.c flash_pb.c locator.c lwiplib.c uartstdio.c ustdlib.c
    ./: commands.c enet_weather.c eth_client.c images.c json.c startup_ewarm.c
    ../drivers/: http.c pinout.c
