# Keil uVision project boot_demo2.uvproj, settings and files
target boot_demo2 (ARM-ADS)
  device: TM4C129ENCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: boot_demo2
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo2.bin .\rvmdk\boot_demo2.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129ENCPDT TARGET_IS_TM4C129_RA2
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: boot_demo2.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo2.c startup_rvmdk.S
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
