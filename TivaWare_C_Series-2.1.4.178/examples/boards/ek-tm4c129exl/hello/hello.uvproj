# Keil uVision project hello.uvproj, settings and files
target hello (ARM-ADS)
  device: TM4C129ENCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: hello
  AfterMake: fromelf --bin --output .\rvmdk\hello.bin .\rvmdk\hello.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129ENCPDT TARGET_IS_TM4C129_RA0
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: hello.sct
  link misc: --entry Reset_Handler
  group Source
    ./: hello.c startup_rvmdk.S
    ../drivers/: pinout.c
    ../../../../utils/: uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
