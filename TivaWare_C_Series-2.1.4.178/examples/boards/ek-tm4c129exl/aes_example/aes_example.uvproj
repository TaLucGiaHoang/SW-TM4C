# Keil uVision project aes_example.uvproj, settings and files
target aes_example (ARM-ADS)
  device: TM4C129ENCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: aes_example
  AfterMake: fromelf --bin --output .\rvmdk\aes_example.bin .\rvmdk\aes_example.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129ENCPDT TARGET_IS_TM4C129_RA2
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: aes_example.sct
  link misc: --entry Reset_Handler
  group Source
    ./: aes_example.c startup_rvmdk.S
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ../drivers/: pinout.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
