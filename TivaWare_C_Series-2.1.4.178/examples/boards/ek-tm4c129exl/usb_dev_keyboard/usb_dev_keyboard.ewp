# IAR project usb_dev_keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129ENCPDT TexasInstruments TM4C129ENCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C129ENCPDT; TARGET_IS_TM4C129_RA0; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: usb_dev_keyboard.bin
  ILINK.IlinkOutputFile: usb_dev_keyboard.out
  ILINK.IlinkIcfFile: usb_dev_keyboard.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: buttons.c pinout.c
    ./: startup_ewarm.c usb_dev_keyboard.c usb_keyb_structs.c
    ../../../../utils/: uartstdio.c
