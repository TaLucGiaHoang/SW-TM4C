# IAR project usb_host_msc.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..; ..\..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_host_msc.bin
  ILINK.IlinkOutputFile: usb_host_msc.out
  ILINK.IlinkIcfFile: usb_host_msc.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ../../../../third_party/fatfs/port/: fat_usbmsc.c
    ../../../../third_party/fatfs/src/: ff.c
    ../drivers/: pinout.c
    ./: startup_ewarm.c usb_host_msc.c
