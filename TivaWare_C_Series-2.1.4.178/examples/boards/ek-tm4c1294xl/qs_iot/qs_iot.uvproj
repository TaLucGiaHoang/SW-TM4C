# Keil uVision project qs_iot.uvproj, settings and files
target qs_iot (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: qs_iot
  AfterMake: fromelf --bin --output .\rvmdk\qs_iot.bin .\rvmdk\qs_iot.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0 LWIP_1_4_1 USE_HTTP_1_0 UART_BUFFERED
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\lwip-1.4.1\apps;..\..\..\..\third_party\exosite;..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include;..\..\..\..\third_party\lwip-1.4.1\src\include;..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: qs_iot.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c eth_client_lwip.c exosite_hal_lwip.c http.c pinout.c
    ../../../../utils/: cmdline.c flash_pb.c locator.c lwiplib.c ringbuf.c uartstdio.c ustdlib.c
    ./: commands.c qs_iot.c requests.c startup_rvmdk.S stats.c tictactoe.c
    ../../../../third_party/exosite/: exosite.c exosite_meta.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
