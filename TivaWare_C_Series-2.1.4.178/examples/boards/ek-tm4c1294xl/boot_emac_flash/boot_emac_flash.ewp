# IAR project boot_emac_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..\..; ..\..\..\..\boot_loader
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: boot_emac_flash.bin
  ILINK.IlinkOutputFile: boot_emac_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\boot_loader\bl_link.icf
  ILINK.IlinkProgramEntryLabel: ResetISR
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../../../../boot_loader/: bl_autobaud.c bl_can.c bl_check.c bl_crc32.c bl_decrypt.c bl_emac.c bl_flash.c bl_i2c.c bl_main.c bl_packet.c bl_ssi.c bl_startup_ewarm.S bl_uart.c bl_usb.c bl_usbfuncs.c
