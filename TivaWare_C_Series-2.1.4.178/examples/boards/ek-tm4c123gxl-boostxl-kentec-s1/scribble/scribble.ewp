# IAR project scribble.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: scribble.bin
  ILINK.IlinkOutputFile: scribble.out
  ILINK.IlinkIcfFile: scribble.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ../drivers/: Kentec320x240x16_ssd2119_spi.c frame.c touch.c
    ../../../../utils/: ringbuf.c ustdlib.c
    ./: scribble.c startup_ewarm.c
