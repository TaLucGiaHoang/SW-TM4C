# Keil uVision project scribble.uvproj, settings and files
target scribble (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: scribble
  AfterMake: fromelf --bin --output .\rvmdk\scribble.bin .\rvmdk\scribble.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: scribble.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: Kentec320x240x16_ssd2119_spi.c frame.c touch.c
    ../../../../utils/: ringbuf.c ustdlib.c
    ./: scribble.c startup_rvmdk.S
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
