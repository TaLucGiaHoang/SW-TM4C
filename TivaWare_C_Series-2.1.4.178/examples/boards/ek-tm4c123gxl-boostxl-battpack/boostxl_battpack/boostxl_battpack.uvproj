# Keil uVision project boostxl_battpack.uvproj, settings and files
target boostxl_battpack (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: boostxl_battpack
  AfterMake: fromelf --bin --output .\rvmdk\boostxl_battpack.bin .\rvmdk\boostxl_battpack.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: boostxl_battpack.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boostxl_battpack.c startup_rvmdk.S
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ../drivers/: rgb.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
  group Documentation
    ./: readme.txt
