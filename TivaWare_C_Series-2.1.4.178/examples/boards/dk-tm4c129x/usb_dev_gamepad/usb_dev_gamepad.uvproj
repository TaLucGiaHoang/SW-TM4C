# Keil uVision project usb_dev_gamepad.uvproj, settings and files
target usb_dev_gamepad (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: usb_dev_gamepad
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_gamepad.bin .\rvmdk\usb_dev_gamepad.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_TM4C129_RA0
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: usb_dev_gamepad.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c frame.c kentec320x240x16_ssd2119.c pinout.c touch.c
    ./: startup_rvmdk.S usb_dev_gamepad.c usb_gamepad_structs.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
