# IAR project usb_host_audio.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  ICCARM.CCDefines: ewarm; PART_TM4C129XNCZAD; TARGET_IS_TM4C129_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..; ..\..\..\..\third_party; ..\..\..\..\utils
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_host_audio.bin
  ILINK.IlinkOutputFile: usb_host_audio.out
  ILINK.IlinkIcfFile: usb_host_audio.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: buttons.c frame.c kentec320x240x16_ssd2119.c pinout.c touch.c usb_sound.c
    ../../../../third_party/fatfs/src/: ff.c
    ../../../../third_party/fatfs/port/: mmc-dk-tm4c129x.c
    ./: startup_ewarm.c usb_host_audio.c
    ../../../../utils/: ustdlib.c wavfile.c
