# Keil uVision project enet_io.uvproj, settings and files
target enet_io (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: enet_io
  AfterMake: fromelf --bin --output .\rvmdk\enet_io.bin .\rvmdk\enet_io.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_TM4C129_RA0 EK_TM4C129_BP1
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\lwip-1.4.1\apps;..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include;..\..\..\..\third_party\lwip-1.4.1\src\include;..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: enet_io.sct
  link misc: --entry Reset_Handler
  group Source
    ./: cgifuncs.c enet_io.c io.c io_fs.c startup_rvmdk.S
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c
    ../../../../third_party/lwip-1.4.1/apps/httpserver_raw/: httpd.c
    ../../../../utils/: locator.c lwiplib.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
