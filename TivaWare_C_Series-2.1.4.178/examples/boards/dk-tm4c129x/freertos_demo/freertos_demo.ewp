# IAR project freertos_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  ICCARM.CCDefines: ewarm; PART_TM4C129XNCZAD; TARGET_IS_TM4C129_RA0; SNOWFLAKE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..; ..\..\..\..\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\third_party\FreeRTOS; ..\..\..\..\third_party\lwip-1.4.1\apps; ..\..\..\..\third_party\FreeRTOS\Source\include; ..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\..\..\third_party\lwip-1.4.1\src\include; ..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_demo.bin
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkIcfFile: freertos_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ./: cgifuncs.c display_task.c freertos_demo.c fs.c idle_task.c images.c led_task.c lwip_task.c random.c spider_task.c startup_ewarm.c
    ../../../../third_party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c touch.c
    ../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../third_party/lwip-1.4.1/apps/httpserver_raw/: httpd.c
    ../../../../utils/: locator.c lwiplib.c ustdlib.c
    ../../../../third_party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.S
