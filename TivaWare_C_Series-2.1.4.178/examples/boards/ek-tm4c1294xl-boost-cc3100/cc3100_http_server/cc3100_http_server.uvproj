# Keil uVision project cc3100_http_server.uvproj, settings and files
target cc3100_http_server (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: cc3100_http_server
  AfterMake: fromelf --bin --output .\rvmdk\cc3100_http_server.bin .\rvmdk\cc3100_http_server.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA1 _USE_CLI_
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\cc3100-sdk\examples\common;..\drivers;..\..\..\..\cc3100-sdk\simplelink\include;..\..\..\..\cc3100-sdk\simplelink\;..\..\..\..\cc3100-sdk\simplelink\source;..\..\..\..\cc3100-sdk\platform\tiva-c-connected-launchpad;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: cc3100_http_server.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../../cc3100-sdk/platform/tiva-c-connected-launchpad/: board.c spi.c
    ../drivers/: buttons.c pinout.c
    ./: cc3100_http_server.c io.c startup_rvmdk.S
    ../../../../cc3100-sdk/simplelink/: cc3100lib.c
    ../../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
