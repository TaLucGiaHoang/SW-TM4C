# IAR project cc3100_http_server.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA1; _USE_CLI_
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..; ..\..\..\..\cc3100-sdk\examples\common; ..\drivers; ..\..\..\..\cc3100-sdk\simplelink\include; ..\..\..\..\cc3100-sdk\simplelink\; ..\..\..\..\cc3100-sdk\simplelink\source; ..\..\..\..\cc3100-sdk\platform\tiva-c-connected-launchpad
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cc3100_http_server.bin
  ILINK.IlinkOutputFile: cc3100_http_server.out
  ILINK.IlinkIcfFile: cc3100_http_server.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../../../../cc3100-sdk/platform/tiva-c-connected-launchpad/: board.c spi.c
    ../drivers/: buttons.c pinout.c
    ./: cc3100_http_server.c io.c startup_ewarm.c
    ../../../../cc3100-sdk/simplelink/: cc3100lib.c
    ../../../../utils/: uartstdio.c ustdlib.c
