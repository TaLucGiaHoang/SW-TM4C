# IAR project nfc_p2p_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: nfc_p2p_demo.bin
  ILINK.IlinkOutputFile: nfc_p2p_demo.out
  ILINK.IlinkIcfFile: nfc_p2p_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../drivers/: buttons.c pinout.c
    ../../../../nfclib/: iso14443a.c llcp.c nfc.c nfc_dep.c nfc_f.c nfc_p2p.c snep.c ssitrf79x0.c trf79x0.c
    ./: nfc_p2p_demo.c nfc_p2p_demo_debug.c startup_ewarm.c
    ../../../../utils/: ringbuf.c uartstdio.c ustdlib.c ustdlib.c
