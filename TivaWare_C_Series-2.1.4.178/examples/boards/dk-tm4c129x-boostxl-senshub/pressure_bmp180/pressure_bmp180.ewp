# IAR project pressure_bmp180.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  ICCARM.CCDefines: ewarm; PART_TM4C129XNCZAD; TARGET_IS_TM4C129_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: pressure_bmp180.bin
  ILINK.IlinkOutputFile: pressure_bmp180.out
  ILINK.IlinkIcfFile: pressure_bmp180.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
    ../../../../sensorlib/ewarm/Exe/: sensorlib.a
  group Source
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c
    ./: pressure_bmp180.c startup_ewarm.c
    ../../../../utils/: uartstdio.c ustdlib.c
