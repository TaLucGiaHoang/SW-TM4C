# IAR project airmouse.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  ICCARM.CCDefines: ewarm; PART_TM4C129XNCZAD; TARGET_IS_TM4C129_RA0; SNOWFLAKE; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: airmouse.bin
  ILINK.IlinkOutputFile: airmouse.out
  ILINK.IlinkIcfFile: airmouse.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
    ../../../../sensorlib/ewarm/Exe/: sensorlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ./: airmouse.c lprf.c motion.c remoti_npi.c remoti_rtis.c remoti_uart.c startup_ewarm.c usb_dev_comp_hid.c usb_structs.c
    ../drivers/: buttons.c frame.c kentec320x240x16_ssd2119.c pinout.c
    ../../../../utils/: ringbuf.c uartstdio.c ustdlib.c
