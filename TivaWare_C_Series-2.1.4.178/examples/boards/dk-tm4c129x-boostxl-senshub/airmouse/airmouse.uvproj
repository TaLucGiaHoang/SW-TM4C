# Keil uVision project airmouse.uvproj, settings and files
target airmouse (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: airmouse
  AfterMake: fromelf --bin --output .\rvmdk\airmouse.bin .\rvmdk\airmouse.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_TM4C129_RA0 SNOWFLAKE UART_BUFFERED
  c misc: --c99
  c include: .;..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: airmouse.sct
  link misc: --entry Reset_Handler
  group Source
    ./: airmouse.c lprf.c motion.c remoti_npi.c remoti_rtis.c remoti_uart.c startup_rvmdk.S usb_dev_comp_hid.c usb_structs.c
    ../drivers/: buttons.c frame.c kentec320x240x16_ssd2119.c pinout.c
    ../../../../utils/: ringbuf.c uartstdio.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
