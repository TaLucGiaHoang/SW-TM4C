# Keil uVision project compdcm_mpu9150.uvproj, settings and files
target compdcm_mpu9150 (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: compdcm_mpu9150
  AfterMake: fromelf --bin --output .\rvmdk\compdcm_mpu9150.bin .\rvmdk\compdcm_mpu9150.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_TM4C129_RA0 UART_BUFFERED
  c misc: --c99
  c include: .;..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: compdcm_mpu9150.sct
  link misc: --entry Reset_Handler
  group Source
    ./: compdcm_mpu9150.c startup_rvmdk.S
    ../drivers/: frame.c kentec320x240x16_ssd2119.c pinout.c
    ../../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
  group Documentation
    ./: readme.txt
